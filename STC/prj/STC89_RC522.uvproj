# Keil uVision project STC89_RC522.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC11F32XE STC11F32XE Series
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: STC11_RC522 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ../code/: ctrl.c ctrl.h include.h main.c main.h rc522.c rc522.h stc11.h timer.c timer.h uart.c uart.h key.h key.c lcd12864.c
